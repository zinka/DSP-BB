options:
  parameters:
    generate_options: qt_gui
    id: top_block_adder
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/zinka/Desktop/Github_Clones/DSP-BB/test/cocotb/sum.bin
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: file_source_0
  id: blocks_file_source
  parameters:
    file: /home/zinka/Desktop/Github_Clones/DSP-BB/test/cocotb/a.bin
    repeat: 'False'
    type: float
  states: {}
- name: file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/zinka/Desktop/Github_Clones/DSP-BB/test/cocotb/b.bin
    repeat: 'False'
    type: float
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle_0_0, '0', blocks_add_xx_0, '1']
- [file_source_0, '0', blocks_throttle_0, '0']
- [file_source_0_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
