options:
  parameters:
    generate_options: no_gui
    id: unsigned_multiply_gr
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data_prod.bin
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: file_source_0
  id: blocks_file_source
  parameters:
    file: data_a.bin
    repeat: 'False'
    type: float
  states: {}
- name: file_source_0_0
  id: blocks_file_source
  parameters:
    file: data_b.bin
    repeat: 'False'
    type: float
  states: {}
- name: relative_path
  id: epy_module
  parameters:
    source_code: |-
      import os

      script_path = os.path.dirname(os.path.realpath(__file__))
      os.chdir(script_path)
  states: {}

connections:
- [blocks_multiply_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle_0_0, '0', blocks_multiply_xx_0, '1']
- [file_source_0, '0', blocks_throttle_0, '0']
- [file_source_0_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
