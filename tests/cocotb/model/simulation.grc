options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/zinka/Desktop/Github_Clones/DSP-BB/tmp.bin
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: doubler
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      # # calling my own modules/functions
      # import os
      # import sys
      # CWD = os.getcwd()
      # sys.path.insert(0,CWD+"/tests/cocotb/model")

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: '2'
  states: {}
- name: file_source_0
  id: blocks_file_source
  parameters:
    file: /home/zinka/Desktop/Github_Clones/DSP-BB/tmp.bin
    repeat: 'False'
    type: float
  states: {}

connections:
- [blocks_throttle_0, '0', doubler, '0']
- [doubler, '0', blocks_file_sink_0, '0']
- [file_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
